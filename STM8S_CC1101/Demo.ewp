# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: App; Bsp; Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group App
    App/: drv_CC1101.c drv_CC1101.h drv_CC1101_Reg.h main.c main.h stm8s_conf.h stm8s_it.c
  group Bsp
    Bsp/: drv_button.c drv_button.h drv_delay.c drv_delay.h drv_exint.c drv_exint.h drv_led.c drv_led.h drv_spi.c drv_spi.h drv_timer1.c drv_timer1.h drv_uart.c drv_uart.h
  group Doc
    Doc/: ReadMe.txt
  group STM8S_StdPeriph_Driver
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_uart1.c
